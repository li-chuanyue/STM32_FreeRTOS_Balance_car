# Keil uVision project F103_FreeRTOS_Template.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F103_FreeRTOS_Template +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: C:\Users\20591\software\Keil_mdk\packs\ARM\CMSIS\6.1.0\CMSIS\Core\Include;C:\Users\20591\software\Keil_mdk\packs\Keil\STM32F1xx_DFP\2.4.1\Device\StdPeriph_Driver\inc;..\Config;..\User;..\FreeRTOS;..\FreeRTOS\portable\GCC\ARM_CM3;..\FreeRTOS\portable\MemMang;..\FreeRTOS\include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./: main.c
    ../Config/: stm32f10x_conf.h
  group Startup
    ../Startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../CMSIS/: system_stm32f10x.c
  group Standart Peripheral Library
    ../Standard_Peripheral_Library/: stm32f10x_gpio.c stm32f10x_rcc.c
    C:/Users/20591/software/Keil_mdk/packs/Keil/STM32F1xx_DFP/2.4.1/Device/StdPeriph_Driver/src/: stm32f10x_tim.c stm32f10x_i2c.c
  group HARDWARE
    ./: Motor_Driver.c oled.c ICM20948.c Encoder.c
  group FreeRTOS Kernel
    ../FreeRTOS/: tasks.c queue.c list.c
    ../FreeRTOS/portable/GCC/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../User/: FreeRTOSConfig.h
